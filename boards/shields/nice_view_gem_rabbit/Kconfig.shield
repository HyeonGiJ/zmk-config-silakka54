## boards/shields/nice_view_gem_rabbit/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_GEM_RABBIT
    def_bool $(shields_list_contains,nice_view_gem_rabbit)
```
